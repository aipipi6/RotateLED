# Keil uVision project RotateLED.uvprojx, settings and files
target TBOX (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RotateLED
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\Drivers\Device\IIC;..\Drivers\Device\GPIO;..\Drivers\Device\TIM;..\Drivers\Device\24CXX;..\Projects;..\STM32F10x_lib\CMSIS;..\STM32F10x_lib\FWLib\inc;..\Projects;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Drivers;..\APP;..\APP\common;..\APP\uart;..\APP\msgParser;..\APP\fontUpdate
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../STM32F10x_lib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../STM32F10x_lib/CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWLIB
    ../STM32F10x_lib/FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c
  group DRIVERS
    ../Drivers/Device/GPIO/: gpio.c
    ../Drivers/Device/TIM/: timer.c
    ../Drivers/Device/IIC/: myiic.c
    ../Drivers/Device/24CXX/: 24cxx.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group APP
    ../APP/uart/: uart_manager.c
    ../APP/common/: common_utils.c
    ../APP/msgParser/: msg_parser.c
    ../APP/fontUpdate/: font_update.c
